# Keil uVision project gongceng.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: gongceng +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD
  c include: ..\103C8T6Lib\inc;..\Core;..\User;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\WokePace\LED;..\Freertos;..\Freertos\include;..\Freertos\portable\MemMang;..\Freertos\portable\RVDS\ARM_CM3;..\User;..\SYSTEM\sys;..\Library
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ../User/: main.c stm32f10x_it.c system_stm32f10x.c FreeRTOSConfig.h freeRTOS_demo.c freeRTOS_demo.h
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group C8T6Lib
    ../103C8T6Lib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group Core
    ../Core/: core_cm3.c startup_stm32f10x_md.s
  group WokePace
    ../WokePace/LED/: led.c
  group FreeRTOS_CORE
    ../Freertos/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group FreeRTOS_PORT
    ../Freertos/portable/MemMang/: heap_4.c
    ../Freertos/portable/RVDS/ARM_CM3/: port.c
  group Library
    ../Library/: oled.c oled.h oled_f.h
